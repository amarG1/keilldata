# Keil uVision project amar.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89LPC9251 NXP
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000) MODP2
  output: amar
  c flags: Optimize=8 SizeSpeed=1
